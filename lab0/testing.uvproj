# Keil uVision project testing.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: testing
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  group Source Group 1
    ./: startup_cm4.s testmain.s
